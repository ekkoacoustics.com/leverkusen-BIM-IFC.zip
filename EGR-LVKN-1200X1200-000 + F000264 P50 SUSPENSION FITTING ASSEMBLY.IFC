Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Leverkusen\EGR-LVKN-1200X1200-000 + F000264 P50 SUSPENSION FITTING ASSEMBLY.IFC
Time: 2024-11-29T14:26:31+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 21.1772143642700996; Volume Measure: 0.0211772143642701; Area Measure: 4.1673005920787469

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 21.1772143642700996; Volume Measure: 0.0211772143642701; Area Measure: 4.1673005920787469

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 21.1772143642700996; Volume Measure: 0.0211772143642701; Area Measure: 4.1673005920787469

# IfcBuildingElementProxy (38)
In: default BuildingStorey
Name
EGR-LVKN-1200X1200-000 + F000264 P50 SUSPENSION FITTING ASSEMBLY | PSet_Mass_Property - Mass Measure: 21.1772143642700996; Volume Measure: 0.0211772143642701; Area Measure: 4.1673005920787469
H Section Hanging Extrusion - 100mm
F000264 P50 SUSPENSION FITTING.SLDPRT
6 x F000264 P50 Tensile Steel Wire 2m
6 x F000264 P50 Top Threaded Insert
6 x F000264 P50 Clutch Fitting
6 x F000264 P50 M5 Threaded Bolt
H Section Hanging Extrusion - 100mm-1
F000264 P50 SUSPENSION FITTING.SLDPRT-1
H Section Hanging Extrusion - 100mm-2
F000264 P50 SUSPENSION FITTING.SLDPRT-2
H Section Hanging Extrusion - 100mm-3
F000264 P50 SUSPENSION FITTING.SLDPRT-3
EGR-LVKN-1200x1200-000 LEVERKUSEN
H Section Hanging Extrusion - 100mm-4
H Section Hanging Extrusion - 100mm-5
F000264 P50 SUSPENSION FITTING.SLDPRT-4
F000264 P50 SUSPENSION FITTING.SLDPRT-5
