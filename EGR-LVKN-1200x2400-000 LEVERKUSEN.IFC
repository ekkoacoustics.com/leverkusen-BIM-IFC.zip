Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Leverkusen\EGR-LVKN-1200x2400-000 LEVERKUSEN.IFC
Time: 2024-11-29T14:28:14+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 37.7922153763545339; Volume Measure: 0.0377922153763545; Area Measure: 7.1809898615517262

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 37.7922153763545339; Volume Measure: 0.0377922153763545; Area Measure: 7.1809898615517262

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 37.7922153763545339; Volume Measure: 0.0377922153763545; Area Measure: 7.1809898615517262

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGR-LVKN-1200x2400-000 LEVERKUSEN | PSet_Mass_Property - Mass Measure: 37.7922153763545339; Volume Measure: 0.0377922153763545; Area Measure: 7.1809898615517262
EGR-LVKN-1200x2400-000 LEVERKUSEN
