Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Leverkusen\H Section Hanging Extrusion - 100mm.IFC
Time: 2024-11-29T14:32:53+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 0.0140403325866419; Volume Measure: 0.0000140403325866; Area Measure: 0.0141898042828845

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 0.0140403325866419; Volume Measure: 0.0000140403325866; Area Measure: 0.0141898042828845

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 0.0140403325866419; Volume Measure: 0.0000140403325866; Area Measure: 0.0141898042828845

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
H Section Hanging Extrusion - 100mm | PSet_Mass_Property - Mass Measure: 0.0140403325866419; Volume Measure: 0.0000140403325866; Area Measure: 0.0141898042828845
H Section Hanging Extrusion - 100mm
