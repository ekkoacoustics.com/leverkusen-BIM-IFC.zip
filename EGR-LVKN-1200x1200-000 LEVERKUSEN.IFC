Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Leverkusen\EGR-LVKN-1200x1200-000 LEVERKUSEN.IFC
Time: 2024-11-29T14:27:17+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 21.0645116700207247; Volume Measure: 0.0210645116700207; Area Measure: 4.0449772614799455

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 21.0645116700207247; Volume Measure: 0.0210645116700207; Area Measure: 4.0449772614799455

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 21.0645116700207247; Volume Measure: 0.0210645116700207; Area Measure: 4.0449772614799455

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGR-LVKN-1200x1200-000 LEVERKUSEN | PSet_Mass_Property - Mass Measure: 21.0645116700207247; Volume Measure: 0.0210645116700207; Area Measure: 4.0449772614799455
EGR-LVKN-1200x1200-000 LEVERKUSEN
