Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Leverkusen\EGR-LVKN-1200X2400-000 + F000264 P50 SUSPENSION FITTING ASSEMBLY.IFC
Time: 2024-11-29T14:29:22+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 38.1303234591026623; Volume Measure: 0.0381303234591026; Area Measure: 7.5479598533481296

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 38.1303234591026623; Volume Measure: 0.0381303234591026; Area Measure: 7.5479598533481296

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 38.1303234591026623; Volume Measure: 0.0381303234591026; Area Measure: 7.5479598533481296

# IfcBuildingElementProxy (110)
In: default BuildingStorey
Name
EGR-LVKN-1200X2400-000 + F000264 P50 SUSPENSION FITTING ASSEMBLY | PSet_Mass_Property - Mass Measure: 38.1303234591026623; Volume Measure: 0.0381303234591026; Area Measure: 7.5479598533481296
H Section Hanging Extrusion - 100mm
F000264 P50 SUSPENSION FITTING.SLDPRT
18 x F000264 P50 Tensile Steel Wire 2m
18 x F000264 P50 Top Threaded Insert
18 x F000264 P50 Clutch Fitting
18 x F000264 P50 M5 Threaded Bolt
F000264 P50 SUSPENSION FITTING.SLDPRT-1
F000264 P50 SUSPENSION FITTING.SLDPRT-2
H Section Hanging Extrusion - 100mm-1
H Section Hanging Extrusion - 100mm-2
F000264 P50 SUSPENSION FITTING.SLDPRT-3
H Section Hanging Extrusion - 100mm-3
H Section Hanging Extrusion - 100mm-4
H Section Hanging Extrusion - 100mm-5
F000264 P50 SUSPENSION FITTING.SLDPRT-4
F000264 P50 SUSPENSION FITTING.SLDPRT-5
H Section Hanging Extrusion - 100mm-6
H Section Hanging Extrusion - 100mm-7
F000264 P50 SUSPENSION FITTING.SLDPRT-6
F000264 P50 SUSPENSION FITTING.SLDPRT-7
F000264 P50 SUSPENSION FITTING.SLDPRT-8
H Section Hanging Extrusion - 100mm-8
H Section Hanging Extrusion - 100mm-9
F000264 P50 SUSPENSION FITTING.SLDPRT-9
H Section Hanging Extrusion - 100mm-10
F000264 P50 SUSPENSION FITTING.SLDPRT-10
F000264 P50 SUSPENSION FITTING.SLDPRT-11
H Section Hanging Extrusion - 100mm-11
H Section Hanging Extrusion - 100mm-12
F000264 P50 SUSPENSION FITTING.SLDPRT-12
F000264 P50 SUSPENSION FITTING.SLDPRT-13
F000264 P50 SUSPENSION FITTING.SLDPRT-14
H Section Hanging Extrusion - 100mm-13
H Section Hanging Extrusion - 100mm-14
F000264 P50 SUSPENSION FITTING.SLDPRT-15
H Section Hanging Extrusion - 100mm-15
F000264 P50 SUSPENSION FITTING.SLDPRT-16
H Section Hanging Extrusion - 100mm-16
F000264 P50 SUSPENSION FITTING.SLDPRT-17
EGR-LVKN-1200x2400-000 LEVERKUSEN
H Section Hanging Extrusion - 100mm-17
